# xar's configure script requires OpenSSL headers and libcrypto.
DEPENDS:append:class-native = " openssl-native"
